<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\NVIC_WFI_Mode.ewp</path>
  </project>
  <batchBuild/>
</workspace>


