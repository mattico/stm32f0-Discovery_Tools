# IAR project PWR_CurrentConsumption.ewp, settings and files
configuration PWR_CurrentConsumption (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051x8 ST STM32F051x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\CMSIS\ST\STM32F0xx\Include; ..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32F0-Discovery
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PWR_CurrentConsumption.srec
  ILINK.IlinkOutputFile: PWR_CurrentConsumption.out
  ILINK.IlinkIcfFile: stm32f0xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../../../../Libraries/CMSIS/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f0xx.s
  group STM32F0-Discovery
    ../../../../Utilities/STM32F0-Discovery/: stm32f0_discovery.c
  group STM32F0xx_StdPeriph_Driver
    ../../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_syscfg.c
  group User
    ../: main.c stm32f0xx_it.c stm32f0xx_lp_modes.c system_stm32f0xx.c
