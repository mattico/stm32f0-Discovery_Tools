# IAR project MKI108V2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F05xxx ST STM32F05xxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.PreInclude: stm32f0xx_conf.h
  ICCARM.CCIncludePath2: .; ..; ..\..; ..\..\..; ..\..\..\..; ..\..\..\Common; ..\..\..\..\Libraries\MikroElektronika\inc; ..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\MEMS_DIL24_Eval-Board\inc; ..\..\..\..\Libraries\MEMS_DIL24_Eval-Board\lsm303dlhc_sw_driver
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MKI108V2.srec
  ILINK.IlinkOutputFile: MKI108V2.out
  ILINK.IlinkIcfFile: stm32f0xx_flash.icf
  ILINK.IlinkExtraOptions: "--no_remove"
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group Libraries/MEMS_DIL24_Library
    ../../../../Libraries/MEMS_DIL24_Eval-Board/lsm303dlhc_sw_driver/: lsm303dlhc_driver.c
    ../../../../Libraries/MEMS_DIL24_Eval-Board/src/: mems_eval_i2c.c
  group Libraries/MikroElektronika
    ../../../../Libraries/MikroElektronika/src/: COG2x16_LCD.c
  group Libraries/STM32_Library
    ../../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c
  group Src
    ../: main.c stm32f0xx_it.c
    ../../../Common/: system_stm32f0xx.c utilities.c
  group Startup
    ../../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f0xx.s
