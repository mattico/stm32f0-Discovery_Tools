# Keil uVision project BLUETOOTH_Click.uvproj, settings and files
target BLUETOOTH_Click (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: BLUETOOTH_Click
  c flags: Optim=1 oTime=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Keil_µVision4;..\..\BLUETOOTH_Click;..\..\..\Common;..\..\..\..\Libraries\MikroElektronika\inc;..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\..\Libraries\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ../../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
  group STM32_Library
    ../../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_tim.c stm32f0xx_exti.c stm32f0xx_misc.c stm32f0xx_syscfg.c stm32f0xx_usart.c
  group MikroElektronika_Library
    ../../../../Libraries/MikroElektronika/src/: uart.c
  group Src
    ../: stm32f0xx_it.c main.c BT_Routines.c
    ../../../Common/: utilities.c system_stm32f0xx.c
