<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\ADC_DMA\EWARM\ADC_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\ADC_LowPower\EWARM\ADC_LowPower.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\DAC_SignalsGeneration\EWARM\DAC_SignalsGeneration.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\DMA_FLASH_RAM\EWARM\DMA_FLASH_RAM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\DMA_RAM_DAC\EWARM\DMA_RAM_DAC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\EXTI\EWARM\EXTI.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\Flash_Program\EWARM\Flash_Program.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\IO_Toggle\EWARM\IO_Toggle.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\IWDG_Reset\EWARM\IWDG_Reset.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\NVIC_WFI_Mode\EWARM\NVIC_WFI_Mode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\PWR_CurrentConsumption\EWARM\PWR_CurrentConsumption.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\PWR_STANDBY\EWARM\PWR_STANDBY.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\PWR_STOP\EWARM\PWR_STOP.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\RCC\EWARM\RCC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Demonstration\EWARM\STM32F0-Discovery_Demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\Systick\EWARM\SysTick.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\TIM_ADC_Trigger\EWARM\TIM_ADC_Trigger.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\TIM_Complementary_signals\EWARM\TIM_Complementary_signals.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\TIM_PWM_Input\EWARM\TIM_PWM_Input.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\TIM_PWM_Output\EWARM\TIM_PWM_Output.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\TIM_TimeBase\EWARM\TIM_TimeBase.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build_All</name>
      <member>
        <project>ADC_DMA</project>
        <configuration>ADC_DMA</configuration>
      </member>
      <member>
        <project>ADC_LowPower</project>
        <configuration>ADC_LowPower</configuration>
      </member>
      <member>
        <project>DAC_SignalsGeneration</project>
        <configuration>DAC_SignalsGeneration</configuration>
      </member>
      <member>
        <project>DMA_FLASH_RAM</project>
        <configuration>DMA_FLASH_RAM</configuration>
      </member>
      <member>
        <project>DMA_RAM_DAC</project>
        <configuration>DMA_RAM_DAC</configuration>
      </member>
      <member>
        <project>EXTI</project>
        <configuration>EXTI</configuration>
      </member>
      <member>
        <project>Flash_Program</project>
        <configuration>Flash_Program</configuration>
      </member>
      <member>
        <project>IO_Toggle</project>
        <configuration>IO_Toggle</configuration>
      </member>
      <member>
        <project>IWDG_Reset</project>
        <configuration>IWDG_Reset</configuration>
      </member>
      <member>
        <project>NVIC_WFI_Mode</project>
        <configuration>NVIC_WFI_Mode</configuration>
      </member>
      <member>
        <project>PWR_CurrentConsumption</project>
        <configuration>PWR_CurrentConsumption</configuration>
      </member>
      <member>
        <project>PWR_STANDBY</project>
        <configuration>PWR_STANDBY</configuration>
      </member>
      <member>
        <project>PWR_STOP</project>
        <configuration>PWR_STOP</configuration>
      </member>
      <member>
        <project>RCC</project>
        <configuration>RCC</configuration>
      </member>
      <member>
        <project>STM32F0-Discovery_Demo</project>
        <configuration>STM32F0_Discovery</configuration>
      </member>
      <member>
        <project>SysTick</project>
        <configuration>SysTick</configuration>
      </member>
      <member>
        <project>TIM_ADC_Trigger</project>
        <configuration>TIM_ADC_Trigger</configuration>
      </member>
      <member>
        <project>TIM_Complementary_signals</project>
        <configuration>TIM_Complementary_signals</configuration>
      </member>
      <member>
        <project>TIM_PWM_Input</project>
        <configuration>TIM_PWM_Input</configuration>
      </member>
      <member>
        <project>TIM_PWM_Output</project>
        <configuration>TIM_PWM_Output</configuration>
      </member>
      <member>
        <project>TIM_TimeBase</project>
        <configuration>TIM_TimeBase</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


